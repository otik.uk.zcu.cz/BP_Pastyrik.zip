classdef appka < matlab.apps.AppBase

    % Properties that correspond to app components
    properties (Access = public)
        UIFigure                       matlab.ui.Figure
        SFButton                       matlab.ui.control.Button
        BDButton                       matlab.ui.control.Button
        PFButton                       matlab.ui.control.Button
        CentrlnzenButton               matlab.ui.control.Button
        DistribuovanzenButton          matlab.ui.control.Button
        StavovzvazbaButton             matlab.ui.control.Button
        LQRButton                      matlab.ui.control.Button
        PoruchuaplikovatnavozidloEditFieldLabel  matlab.ui.control.Label
        PoruchuaplikovatnavozidloEditField  matlab.ui.control.EditField
        VyberstrategiiametoduzenLabel  matlab.ui.control.Label
        RozestupvozidellzeupravitEditField  matlab.ui.control.EditField
        RozestupvozidellzeupravitEditFieldLabel  matlab.ui.control.Label
        ZadejvelikostporuchyEditField  matlab.ui.control.EditField
        ZadejvelikostporuchyEditFieldLabel  matlab.ui.control.Label
        Zadejpoetaut310EditField       matlab.ui.control.EditField
        Zadejpoetaut310EditFieldLabel  matlab.ui.control.Label
        PoetvozidelEditField           matlab.ui.control.EditField
        PoetvozidelEditFieldLabel      matlab.ui.control.Label
        UkonitButton                   matlab.ui.control.Button
        NastavButton                   matlab.ui.control.Button
        SimulovatButton                matlab.ui.control.Button
        DistribuovanLQRButton          matlab.ui.control.Button
        SymetrickButton                matlab.ui.control.Button
        UIAxes3                        matlab.ui.control.UIAxes
        UIAxes2                        matlab.ui.control.UIAxes
        UIAxes                         matlab.ui.control.UIAxes
    end

    
    properties (Access = public)
        rizeni
        maximum
        topo
    end
    
    methods (Access = public)
        
        function [auto,primka,cisla] = generuj(app,n,mezera)
            poloha = zeros(1,n);
            for i=1:n
                poloha(i) = i+mezera*(i-1);
            end
                        
            C = {'c','m','b','r','g',[0.4660 0.6740 0.1880],'y',[0.6350 0.0780 0.1840],[0 0.4470 0.7410],[0.9290 0.6940 0.1250]};
            for i=1:n
                auto(i) = rectangle(app.UIAxes, 'Position', [poloha(n+1-i) 0 1 1],'EdgeColor','k','FaceColor', C{i});
                primka(i) = rectangle(app.UIAxes, 'Position', [poloha(n+1-i)+1 1/2 mezera 1/100],'EdgeColor','r');
                cisla(i) = text(app.UIAxes, poloha(n+1-i)+1/2,1/2, int2str(i),'HorizontalAlignment','center');

            end           
        end
    end
   

    % Callbacks that handle component events
    methods (Access = private)

        % Button pushed function: NastavButton
        function NastavButtonPushed(app, event)
            app.SimulovatButton.Enable = 'on';
            app.NastavButton.Enable = 'off';
            app.Zadejpoetaut310EditField.Enable = 'off';
            app.RozestupvozidellzeupravitEditField.Editable = 'on';
            app.RozestupvozidellzeupravitEditField.Value = '2';
            app.PoetvozidelEditField.Value = app.Zadejpoetaut310EditField.Value;
        end

        % Button pushed function: UkonitButton
        function UkonitButtonPushed(app, event)
            close all;
            app.delete;
        end

        % Value changed function: Zadejpoetaut310EditField
        function Zadejpoetaut310EditFieldValueChanged(app, event)
            value = app.Zadejpoetaut310EditField.Value;
            if str2double(value) < 3
                app.Zadejpoetaut310EditField.Value = "3";
            elseif str2double(value) > app.maximum
                if app.rizeni == 1
                    app.Zadejpoetaut310EditField.Value = "10";
                elseif app.rizeni == 2
                    app.Zadejpoetaut310EditField.Value = "5";
                elseif app.rizeni == 3
                    app.Zadejpoetaut310EditField.Value = "8";
                else
                    app.Zadejpoetaut310EditField.Value = "3";
                end     
            end
            app.NastavButton.Enable = 'on';           
        end

        % Button pushed function: SimulovatButton
        function SimulovatButtonPushed(app, event)
            app.PoruchuaplikovatnavozidloEditField.Enable = 'on';
            app.SimulovatButton.Enable = 'off';
            app.PoetvozidelEditField.Editable = 'off';
            mezera = str2double(app.RozestupvozidellzeupravitEditField.Value);
            pocet = str2double(app.Zadejpoetaut310EditField.Value);
            
            N = pocet;
            [auto,primka,cisla] = generuj(app,pocet,mezera);
            if app.rizeni == 1
                [~,B1,C1,D1,Az1,~,~,~] = appLQR(N); 
            elseif app.rizeni == 2
                [~,B1,C1,D1,Az1,~,~,~] = appSYM(N); 
            elseif app.rizeni == 3
                [~,B1,C1,D1,Az1,~,~,~] = appDekompLQR(N); 
            else
                [~,B1,C1,D1,Az1,~,~,~] = appSZV(N,app.topo); 
            end         
            eig(Az1)
            porucha1 = B1;
            pocet_stavu = 2*N-1;

            sys = ss(Az1,porucha1,C1,D1);
            sysd = c2d(sys,0.1,'zoh');
            Azd = sysd.A;
            poruchad = sysd.B;
            max = 500;
            x = zeros(pocet_stavu,max);
            u = zeros(pocet,max);
            k = 1;
            poloha = zeros(1,N);
            
            a=1:2*N-1;
            sude=a(mod(a,2)==0);    % sude prenosy odpovidaji z poruchy na odchylky poloh            
            odch_p = app.UIAxes2;  %Assign your axes to variable
            hold(odch_p, 'on')
            
            liche=a(mod(a,2)==1);
            odch_r = app.UIAxes3;  %Assign your axes to variable
            hold(odch_r, 'on')
            suma = 0;
            while isvalid(app)
                temp = mezera;
                mezera = str2double(app.RozestupvozidellzeupravitEditField.Value);
                if temp == mezera
                else
                    for i=1:N
                        poloha(i) = i+mezera*(i-1);
                    end                  
                end
                chyba = str2double(app.PoruchuaplikovatnavozidloEditField.Value);
                if chyba == 0
                    vstup = 0;                   
                    chyba = 1;
                else
                    vstup = str2double(app.ZadejvelikostporuchyEditField.Value);
                    app.ZadejvelikostporuchyEditField.Enable = 'on';
                end
                                   
                u(chyba,k) = vstup;
                if vstup == 0
                    
                else
                    t = timer;
                    t.StartDelay = 3;
                    t.TimerFcn = set(app.ZadejvelikostporuchyEditField, 'Value', '0');
                    app.ZadejvelikostporuchyEditField.Enable = 'off';
                    t.TimerFcn = set(app.PoruchuaplikovatnavozidloEditField, 'Value', '0');
                end
                x(:,k+1) = Azd*x(:,k) + poruchad*u(:,k);
                y(:,k) = C1*x(:,k);
                
                plot(odch_p,y(sude(1),:),'c')
                plot(odch_p,y(sude(2),:), 'm')
                switch N
                    case 4
                        plot(odch_p,y(sude(3),:),'b')
                    case 5
                        plot(odch_p,y(sude(3),:),'b')
                        plot(odch_p,y(sude(4),:),'r')
                    case 6
                        plot(odch_p,y(sude(3),:),'b')
                        plot(odch_p,y(sude(4),:),'r')
                        plot(odch_p,y(sude(5),:),'g')
                    case 7
                        plot(odch_p,y(sude(3),:),'b')
                        plot(odch_p,y(sude(4),:),'r')
                        plot(odch_p,y(sude(5),:),'g')
                        plot(odch_p,y(sude(6),:),'Color' ,[0.4660 0.6740 0.1880])
                    case 8
                        plot(odch_p,y(sude(3),:),'b')
                        plot(odch_p,y(sude(4),:),'r')
                        plot(odch_p,y(sude(5),:),'g')
                        plot(odch_p,y(sude(6),:),'Color' ,[0.4660 0.6740 0.1880])
                        plot(odch_p,y(sude(7),:),'y')
                    case 9
                        plot(odch_p,y(sude(3),:),'b')
                        plot(odch_p,y(sude(4),:),'r')
                        plot(odch_p,y(sude(5),:),'g')
                        plot(odch_p,y(sude(6),:),'Color' ,[0.4660 0.6740 0.1880])
                        plot(odch_p,y(sude(7),:),'y')
                        plot(odch_p,y(sude(8),:),'Color' ,[0.6350 0.0780 0.1840])
                    case 10
                        plot(odch_p,y(sude(3),:),'b')
                        plot(odch_p,y(sude(4),:),'r')
                        plot(odch_p,y(sude(5),:),'g')
                        plot(odch_p,y(sude(6),:),'Color' ,[0.4660 0.6740 0.1880])
                        plot(odch_p,y(sude(7),:),'y')
                        plot(odch_p,y(sude(8),:),'Color' ,[0.6350 0.0780 0.1840])
                        plot(odch_p,y(sude(9),:),'Color' ,[0 0.4470 0.7410])   
                end
                
                plot(odch_r,y(liche(1),:),'c')
                plot(odch_r,y(liche(2),:), 'm')
                plot(odch_r,y(liche(3),:),'b')
                
                switch N
                    case 4
                        plot(odch_r,y(liche(4),:),'r')
                    case 5
                        plot(odch_r,y(liche(4),:),'r')
                        plot(odch_r,y(liche(5),:),'g')
                    case 6
                        plot(odch_r,y(liche(4),:),'r')
                        plot(odch_r,y(liche(5),:),'g')
                        plot(odch_r,y(liche(6),:),'Color' ,[0.4660 0.6740 0.1880])
                    case 7
                        plot(odch_r,y(liche(4),:),'r')
                        plot(odch_r,y(liche(5),:),'g')
                        plot(odch_r,y(liche(6),:),'Color' ,[0.4660 0.6740 0.1880])
                        plot(odch_r,y(liche(7),:),'y')                        
                    case 8
                        plot(odch_r,y(liche(4),:),'r')
                        plot(odch_r,y(liche(5),:),'g')
                        plot(odch_r,y(liche(6),:),'Color' ,[0.4660 0.6740 0.1880])
                        plot(odch_r,y(liche(7),:),'y')
                        plot(odch_r,y(liche(8),:),'Color' ,[0.6350 0.0780 0.1840])
                    case 9
                        plot(odch_r,y(liche(4),:),'r')
                        plot(odch_r,y(liche(5),:),'g')
                        plot(odch_r,y(liche(6),:),'Color' ,[0.4660 0.6740 0.1880])
                        plot(odch_r,y(liche(7),:),'y')
                        plot(odch_r,y(liche(8),:),'Color' ,[0.6350 0.0780 0.1840])
                        plot(odch_r,y(liche(9),:),'Color' ,[0 0.4470 0.7410])
                    case 10
                        plot(odch_r,y(liche(4),:),'r')
                        plot(odch_r,y(liche(5),:),'g')
                        plot(odch_r,y(liche(6),:),'Color' ,[0.4660 0.6740 0.1880])
                        plot(odch_r,y(liche(7),:),'y')
                        plot(odch_r,y(liche(8),:),'Color' ,[0.6350 0.0780 0.1840])
                        plot(odch_r,y(liche(9),:),'Color' ,[0 0.4470 0.7410])
                        plot(odch_r,y(liche(10),:),'Color' ,[0.9290 0.6940 0.1250])    
                end                                
                
                for i=1:pocet
                    poloha(i) = i+mezera*(i-1);
                end
                    
                for i=1:N
                    if i == N
                        auto(i).Position = [poloha(pocet+1-i) 0 1 1];
                        primka(i).Position = [poloha(pocet+1-i)+1 1/2 mezera 1/100];
                        cisla(i).Position = [poloha(pocet+1-i)+1/2 1/2 0];
                    else
                        auto(i).Position = [(poloha(pocet+1-i)+y(2*i,k)) 0 1 1];
                        primka(i).Position = [(poloha(pocet+1-i)+1+y(2*i,k)) 1/2 mezera 1/100];
                        cisla(i).Position = [(poloha(pocet+1-i)+1/2+y(2*i,k)) 1/2 0];
                    end
                    
                   
                end         
%                 pause(0.25) 
                pause(0.4) 
                k = k+1;
                if k == max
                    assignin("base","u", u);
                    assignin("base","x", x);
                    assignin("base","y", y);
                    break;
                end
            end
        end

        % Button pushed function: LQRButton
        function LQRButtonPushed(app, event)
            app.LQRButton.Enable = 'off';
            app.SymetrickButton.Enable = 'off';
            app.Zadejpoetaut310EditField.Editable = 'on';
            app.rizeni = 1;
            app.maximum = 10;
            app.LQRButton.BackgroundColor = [0.00,1.00,0.00];
        end

        % Button pushed function: SymetrickButton
        function SymetrickButtonPushed(app, event)
            app.LQRButton.Enable = 'off';
            app.SymetrickButton.Enable = 'off';
            app.Zadejpoetaut310EditField.Editable = 'on';
            app.rizeni = 2;
            app.maximum = 5;
            app.Zadejpoetaut310EditFieldLabel.Text = 'Zadej počet aut <3;5>';
            app.SymetrickButton.BackgroundColor = [0.00,1.00,0.00];
        end

        % Value changed function: PoruchuaplikovatnavozidloEditField
        function PoruchuaplikovatnavozidloEditFieldValueChanged(app, event)
            value = app.PoruchuaplikovatnavozidloEditField.Value;            
            if str2double(value) < 0
                app.PoruchuaplikovatnavozidloEditField.Value = "0";
            elseif str2double(value) > str2double(app.Zadejpoetaut310EditField.Value)
                app.PoruchuaplikovatnavozidloEditField.Value = app.Zadejpoetaut310EditField.Value;
            end
        end

        % Button pushed function: CentrlnzenButton
        function CentrlnzenButtonPushed(app, event)
            app.LQRButton.Visible = 'on';
            app.SymetrickButton.Visible = 'on';
            app.CentrlnzenButton.Visible = 'off';
            app.DistribuovanzenButton.Visible = 'off';
        end

        % Button pushed function: DistribuovanzenButton
        function DistribuovanzenButtonPushed(app, event)
            app.StavovzvazbaButton.Visible = 'on';
            app.DistribuovanLQRButton.Visible = 'on';
            app.DistribuovanzenButton.Visible = 'off';
            app.CentrlnzenButton.Visible = 'off';
        end

        % Button pushed function: StavovzvazbaButton
        function StavovzvazbaButtonPushed(app, event)
            app.StavovzvazbaButton.Enable = 'off';
            app.DistribuovanLQRButton.Enable = 'off';
            app.Zadejpoetaut310EditField.Editable = 'on';
            app.maximum = 3;
            app.PFButton.Visible = 'on';
            app.SFButton.Visible = 'on';
            app.BDButton.Visible = 'on';
            app.rizeni = 4;
            app.StavovzvazbaButton.Visible = 'off';
            app.DistribuovanLQRButton.Visible = 'off';
        end

        % Button pushed function: DistribuovanLQRButton
        function DistribuovanLQRButtonPushed(app, event)
            app.rizeni = 3;
            app.StavovzvazbaButton.Enable = 'off';
            app.DistribuovanLQRButton.Enable = 'off';
            app.Zadejpoetaut310EditField.Editable = 'on';
            app.Zadejpoetaut310EditFieldLabel.Text = 'Zadej počet aut <3;8>';
            app.maximum = 8;
            app.DistribuovanLQRButton.BackgroundColor = [0.00,1.00,0.00];
        end

        % Button pushed function: PFButton
        function PFButtonPushed(app, event)
            app.topo = 1;
            app.PFButton.Enable = 'off';
            app.SFButton.Enable = 'off';
            app.BDButton.Enable = 'off';
            app.PFButton.BackgroundColor = [0.00,1.00,0.00];
            app.Zadejpoetaut310EditFieldLabel.Text = 'Počet aut = 3';
            app.Zadejpoetaut310EditField. Value = '3';
            app.NastavButton.Enable = 'on';
        end

        % Button pushed function: BDButton
        function BDButtonPushed(app, event)
            app.topo = 3;
            app.PFButton.Enable = 'off';
            app.SFButton.Enable = 'off';
            app.BDButton.Enable = 'off';
            app.BDButton.BackgroundColor = [0.00,1.00,0.00];
            app.Zadejpoetaut310EditFieldLabel.Text = 'Počet aut = 3';
            app.Zadejpoetaut310EditField. Value = '3';
            app.NastavButton.Enable = 'on';
        end

        % Button pushed function: SFButton
        function SFButtonPushed(app, event)
            app.topo = 2;
            app.PFButton.Enable = 'off';
            app.SFButton.Enable = 'off';
            app.BDButton.Enable = 'off';
            app.SFButton.BackgroundColor = [0.00,1.00,0.00];
            app.Zadejpoetaut310EditFieldLabel.Text = 'Počet aut = 3';
            app.Zadejpoetaut310EditField. Value = '3';
            app.NastavButton.Enable = 'on';
        end
    end

    % Component initialization
    methods (Access = private)

        % Create UIFigure and components
        function createComponents(app)
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            app.UIFigure = uifigure('Visible', 'off');
            app.UIFigure.Name = 'MATLAB App';
            app.UIAxes = uiaxes(app.UIFigure);
            title(app.UIAxes, 'Vizualizace kolony s požadovanými rozestupy')
            app.UIAxes.YLim = [-1 2];
            app.UIAxes.YTick = [0 1 2 3 4 5];
            app.UIAxes.YTickLabel = {'0'; '1'; '2'; '3'; '4'; '5'};
            app.UIAxes2 = uiaxes(app.UIFigure);
            title(app.UIAxes2, 'Průběh odchylek od polohy vozidel')
            xlabel(app.UIAxes2, 'časové okamžiky k')
            ylabel(app.UIAxes2, 'odchylka od polohy [m]')
            zlabel(app.UIAxes2, 'Z')
            app.UIAxes3 = uiaxes(app.UIFigure);
            title(app.UIAxes3, 'Průběh odchylek od rychlosti vozidel')
            xlabel(app.UIAxes3, 'časový okamžik k')
            ylabel(app.UIAxes3, 'odchylka od rychlosti [m/s]')
            zlabel(app.UIAxes3, 'Z')
            app.SymetrickButton = uibutton(app.UIFigure, 'push');
            app.SymetrickButton.ButtonPushedFcn = createCallbackFcn(app, @SymetrickButtonPushed, true);
            app.SymetrickButton.Visible = 'off';
            app.SymetrickButton.Text = 'Symetrické';
            app.DistribuovanLQRButton = uibutton(app.UIFigure, 'push');
            app.DistribuovanLQRButton.ButtonPushedFcn = createCallbackFcn(app, @DistribuovanLQRButtonPushed, true);
            app.DistribuovanLQRButton.Visible = 'off';
            app.DistribuovanLQRButton.Text = {'Distribuované'; 'LQR'};
            app.SimulovatButton = uibutton(app.UIFigure, 'push');
            app.SimulovatButton.ButtonPushedFcn = createCallbackFcn(app, @SimulovatButtonPushed, true);
            app.SimulovatButton.Enable = 'off';
            app.SimulovatButton.Text = 'Simulovat';
            app.NastavButton = uibutton(app.UIFigure, 'push');
            app.NastavButton.ButtonPushedFcn = createCallbackFcn(app, @NastavButtonPushed, true);
            app.NastavButton.Enable = 'off';
            app.NastavButton.Text = 'Nastav';
            app.UkonitButton = uibutton(app.UIFigure, 'push');
            app.UkonitButton.ButtonPushedFcn = createCallbackFcn(app, @UkonitButtonPushed, true);
            app.UkonitButton.Text = 'Ukončit';
            app.PoetvozidelEditFieldLabel = uilabel(app.UIFigure);
            app.PoetvozidelEditFieldLabel.Text = 'Počet vozidel';
            app.PoetvozidelEditField = uieditfield(app.UIFigure, 'text');
            app.PoetvozidelEditField.Editable = 'off';
            app.Zadejpoetaut310EditFieldLabel = uilabel(app.UIFigure);
            app.Zadejpoetaut310EditFieldLabel.Text = 'Zadej počet aut <3;10>';
            app.Zadejpoetaut310EditField = uieditfield(app.UIFigure, 'text');
            app.Zadejpoetaut310EditField.ValueChangedFcn = createCallbackFcn(app, @Zadejpoetaut310EditFieldValueChanged, true);
            app.Zadejpoetaut310EditField.Editable = 'off';
            app.ZadejvelikostporuchyEditFieldLabel = uilabel(app.UIFigure);
            app.ZadejvelikostporuchyEditFieldLabel.Enable = 'off';
            app.ZadejvelikostporuchyEditFieldLabel.Text = 'Zadej velikost poruchy';
            app.ZadejvelikostporuchyEditField = uieditfield(app.UIFigure, 'text');
            app.ZadejvelikostporuchyEditField.Enable = 'off';
            app.ZadejvelikostporuchyEditField.Value = '0';
            app.RozestupvozidellzeupravitEditFieldLabel = uilabel(app.UIFigure);
            app.RozestupvozidellzeupravitEditFieldLabel.Text = {'Rozestup vozidel'; '(lze upravit)'};
            app.RozestupvozidellzeupravitEditField = uieditfield(app.UIFigure, 'text');
            app.RozestupvozidellzeupravitEditField.Editable = 'off';
            app.VyberstrategiiametoduzenLabel = uilabel(app.UIFigure);
            app.VyberstrategiiametoduzenLabel.Text = 'Vyber strategii a metodu řízení';
            app.PoruchuaplikovatnavozidloEditField = uieditfield(app.UIFigure, 'text');
            app.PoruchuaplikovatnavozidloEditField.ValueChangedFcn = createCallbackFcn(app, @PoruchuaplikovatnavozidloEditFieldValueChanged, true);
            app.PoruchuaplikovatnavozidloEditField.Enable = 'off';
            app.PoruchuaplikovatnavozidloEditField.Value = '0';
            app.PoruchuaplikovatnavozidloEditFieldLabel = uilabel(app.UIFigure);
            app.PoruchuaplikovatnavozidloEditFieldLabel.Enable = 'off';
            app.PoruchuaplikovatnavozidloEditFieldLabel.Text = 'Poruchu aplikovat na vozidlo';
            app.LQRButton = uibutton(app.UIFigure, 'push');
            app.LQRButton.ButtonPushedFcn = createCallbackFcn(app, @LQRButtonPushed, true);
            app.LQRButton.Visible = 'off';
            app.LQRButton.Text = 'LQR';
            app.StavovzvazbaButton = uibutton(app.UIFigure, 'push');
            app.StavovzvazbaButton.ButtonPushedFcn = createCallbackFcn(app, @StavovzvazbaButtonPushed, true);
            app.StavovzvazbaButton.Visible = 'off';
            app.StavovzvazbaButton.Text = {'Stavová z.'; 'vazba'};
            app.DistribuovanzenButton = uibutton(app.UIFigure, 'push');
            app.DistribuovanzenButton.ButtonPushedFcn = createCallbackFcn(app, @DistribuovanzenButtonPushed, true);
            app.DistribuovanzenButton.Text = 'Distribuované řízení';
            app.CentrlnzenButton = uibutton(app.UIFigure, 'push');
            app.CentrlnzenButton.ButtonPushedFcn = createCallbackFcn(app, @CentrlnzenButtonPushed, true);
            app.CentrlnzenButton.Text = 'Centrální řízení';
            app.PFButton = uibutton(app.UIFigure, 'push');
            app.PFButton.ButtonPushedFcn = createCallbackFcn(app, @PFButtonPushed, true);
            app.PFButton.Visible = 'off';
            app.PFButton.Text = 'PF';
            app.BDButton = uibutton(app.UIFigure, 'push');
            app.BDButton.ButtonPushedFcn = createCallbackFcn(app, @BDButtonPushed, true);
            app.BDButton.Visible = 'off';
            app.BDButton.Text = 'BD';
            app.SFButton = uibutton(app.UIFigure, 'push');
            app.SFButton.ButtonPushedFcn = createCallbackFcn(app, @SFButtonPushed, true);
            app.SFButton.Visible = 'off';
            app.SFButton.Text = 'SF';
            % Show the figure after all components are created
            app.UIFigure.Visible = 'on';
        end
    end

    % App creation and deletion
    methods (Access = public)

        % Construct app
        function app = appka

            % Create UIFigure and components
            createComponents(app)

            % Register the app with App Designer
            registerApp(app, app.UIFigure)

            if nargout == 0
                clear app
            end
        end

        % Code that executes before app deletion
        function delete(app)

            % Delete UIFigure when app is deleted
            delete(app.UIFigure)
        end
    end
end